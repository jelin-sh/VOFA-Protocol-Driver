# Keil uVision project vofa_gd32f303rc.uvprojx, settings and files
target Debug (6140001::V6.14.1::ARMCLANG)
  device: GD32F303RC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: vofa
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\VOFA+;..\CMSIS\Core;..\CMSIS\Device\GD32F30x;..\CMSIS\DSP\Inc;..\FWLib\Inc;..\..\GD32F303RC
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application
    ../: delay.c interrupt.c main.c Vofa_GD32F303RC.c
    ../../../VOFA+/: Vofa.c
  group FWLib
    ../FWLib/Src/: gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_timer.c gd32f30x_usart.c
  group CMSIS
    ../CMSIS/Device/GD32F30x/: system_gd32f30x.c startup_gd32f30x_hd.s
    ../CMSIS/DSP/Lib/: arm_cortexM4lf_math.lib
